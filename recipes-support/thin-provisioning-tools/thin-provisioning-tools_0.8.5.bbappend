SRC_URI = "git://github.com/jthornber/thin-provisioning-tools;branch=main \
           file://0001-do-not-strip-pdata_tools-at-do_install.patch \
           file://use-sh-on-path.patch \
"

