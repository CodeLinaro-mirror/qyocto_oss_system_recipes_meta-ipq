FILESEXTRAPATHS:append := "${THISDIR}/files:"
EXTRA_OECONF:remove= "no-md4"
