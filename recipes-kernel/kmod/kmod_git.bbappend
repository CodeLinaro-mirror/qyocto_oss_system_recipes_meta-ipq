FILESEXTRAPATHS:append := "${THISDIR}/files:"
SRC_URI += " file://0002-kmod-insmod-using-module-name.patch "
